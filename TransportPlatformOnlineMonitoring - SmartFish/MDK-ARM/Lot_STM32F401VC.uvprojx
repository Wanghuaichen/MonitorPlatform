# Keil uVision project Lot_STM32F401VC.uvprojx, settings and files
target Lot (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F401RC STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lot_STM32F401VC
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xC
  c include: ..\Inc;..\Inc\Application\Bsp;..\Inc\Application\Task;..\Inc\Application\Driver;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Middlewares\Third_Party\FreeRTOS;..\Middlewares\Third_Party\FreeRTOS\include;..\Middlewares\Third_Party\FreeRTOS\portable\RVDS\ARM_CM4F;..\Middlewares\Third_Party\Fatfs\source
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xc.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
    ../Inc/: FreeRTOSConfig.h UserFreeRTOS.h SysParam.h
  group Application/User/Task
    ../Src/Application/Task/: Task_Debug.c Task_Monitor.c Task_MsgPrint.c Task_MsgManager.c Task_GetGpsMsg.c Task_GetTempMsg.c Task_GetAttiAndAccMsg.c Task_LedAndRelay.c
  group Application/User/Driver
    ../Src/Application/Driver/: DriveDelay.c DriveI2C.c DriveIO.c DriveIWDG.c DriveRS485.c DriveSPI.c DriveTIM.c DriveUSART.c
  group Application/User/Bsp
    ../Src/Application/Bsp/: ADXL345.c DS18B20.c NandFlash.c SD_ReadWrite.c SIM868.c TimeOutDetection.c SystemConfig.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/FAT
    ../Middlewares/Third_Party/Fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group Readme
    ./: Readme.txt
